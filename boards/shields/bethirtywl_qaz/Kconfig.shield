## boards/shields/bethirtywl_qaz/Kconfig.shield
```kconfig
config SHIELD_BETHIRTYWL_QAZ
    def_bool $(shields_list_contains,bethirtywl_qaz)
```
